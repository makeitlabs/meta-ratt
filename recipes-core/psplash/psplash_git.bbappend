FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SPLASH_IMAGES = "file://psplash-ratt-img.h;outsuffix=default"
